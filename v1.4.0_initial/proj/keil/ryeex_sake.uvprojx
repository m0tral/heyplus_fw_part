# Keil uVision project ryeex_sake.uvprojx, settings and files
target ryeex_sake (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: ryeex_sake
  AfterMake: fromelf --bin --output bin\ryeex_sake.bin bin\ryeex_sake.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_PART_APOLLO2 AM_FREERTOS keil  xWSF_TRACE_ENABLED
  c misc: --diag_suppress=177  --diag_suppress=550 --diag_suppress=870  --diag_suppress=1295
  c include: ..\..\bsp;..\..\bsp\apollo2\bsp\apollo2_evk_em9304;..\..\bsp\apollo2\devices;..\..\bsp\apollo2\freertos;..\..\bsp\apollo2\mcu;..\..\bsp\apollo2\mcu\hal;..\..\bsp\apollo2\mcu\regs;..\..\bsp\apollo2\utils;..\..\hal\inc;..\..\ryos\inc;..\..\thirdparty\FreeRTOS9\Source\include;..\..\thirdparty\FreeRTOS9\Source\portable\Keil\AMapollo2;..\..\utils\inc;..\..\ryapi\inc;..\..\bsp\apollo2\exactle\apollo-host\projects\common;..\..\bsp\apollo2\exactle\sw\apps\app;..\..\bsp\apollo2\exactle\sw\apps\app\include;..\..\bsp\apollo2\exactle\sw\apps\fit;..\..\bsp\apollo2\exactle\sw\hci\ambiq;..\..\bsp\apollo2\exactle\sw\hci\include;..\..\bsp\apollo2\exactle\sw\sec\common;..\..\bsp\apollo2\exactle\sw\sec\include;..\..\bsp\apollo2\exactle\sw\services;..\..\bsp\apollo2\exactle\sw\stack\cfg;..\..\bsp\apollo2\exactle\sw\stack\hci;..\..\bsp\apollo2\exactle\sw\stack\include;..\..\bsp\apollo2\exactle\ws-core\include;..\..\bsp\apollo2\exactle\ws-core\sw\util;..\..\bsp\apollo2\exactle\ws-core\sw\wsf\ambiq;..\..\bsp\apollo2\exactle\ws-core\sw\wsf\include;..\..\bsp\apollo2\exactle\sw\profiles\bas;..\..\bsp\apollo2\exactle\sw\profiles\hrps;..\..\bsp\apollo2\exactle\sw\profiles\rscp;..\..\bsp\apollo2\exactle\sw\profiles\uribeacon;..\..\subsystem\ble\inc;..\..\thirdparty\nanopb\inc;..\..\thirdparty\pt;..\..\bsp\components\mc36xx;..\..\bsp\apollo2\bootloader;..\..\thirdparty\nanopb\proto;..\..\bsp\components\bma456;..\..\subsystem\protocol\inc;..\..\subsystem\gsensor\inc;..\..\subsystem\nfc\pn80t\halimpl\pn54x\common;..\..\subsystem\nfc\pn80t\halimpl\pn54x\dnld;..\..\subsystem\nfc\pn80t\halimpl\pn54x\hal;..\..\subsystem\nfc\pn80t\halimpl\pn54x\inc;..\..\subsystem\nfc\pn80t\halimpl\pn54x\log;..\..\subsystem\nfc\pn80t\halimpl\pn54x\osal;..\..\subsystem\nfc\pn80t\halimpl\pn54x\tml;..\..\subsystem\nfc\pn80t\halimpl\pn54x\utils;..\..\subsystem\nfc\pn80t\inc;..\..\subsystem\nfc\pn80t\lib\SeSupport;..\..\subsystem\nfc\pn80t\lib\SeSupport\include;..\..\subsystem\nfc\pn80t\lib\SeSupport\inc;..\..\subsystem\nfc\pn80t\lib\SeSupport\src\mop\inc;..\..\subsystem\nfc\pn80t\SeApi;..\..\subsystem\nfc\pn80t\SeApi\LogSupport;..\..\subsystem\nfc\pn80t\src\gki;..\..\subsystem\nfc\pn80t\src\hal\include;..\..\subsystem\nfc\pn80t\src\hal\int;..\..\subsystem\nfc\pn80t\src\include;..\..\subsystem\nfc\pn80t\src\nfa\include;..\..\subsystem\nfc\pn80t\src\nfa\int;..\..\subsystem\nfc\pn80t\src\nfc\include;..\..\subsystem\nfc\pn80t\src\nfc\int;..\..\subsystem\nfc\pn80t;..\..\subsystem\nfc\pn80t\app\inc;..\..\subsystem\nfc\pn80t\drv\inc;..\..\subsystem\nfc\pn80t\ble\qn_eaci;..\..\subsystem\xfer;..\..\subsystem\gup\inc;..\..\subsystem\tool\inc;..\..\subsystem\gui\inc;..\..\thirdparty\ugfx;..\..\thirdparty\ugfx\drivers\gdisp\rm67162;..\..\resources\img;..\..\thirdparty\jsmn\inc;..\..\bsp\components\touch_oled\inc;..\..\subsystem\hrm\inc;..\..\bsp\components\PPSI26X\inc;..\..\thirdparty\fatfs;..\..\subsystem\app_pm\inc;..\..\subsystem\testbench\inc;..\..\resources\fonts;..\..\subsystem\sensor_alg\inc;..\..\thirdparty\XMODEM;..\..\app;..\..\thirdparty\md5;..\..\thirdparty\k_kernel;..\..\app\app_module;..\..\subsystem\touch\inc;..\..\subsystem\sched\inc;..\..\thirdparty\Freetype\include;..\..\thirdparty\Freetype\include\freetype;..\..\thirdparty\Freetype\include\freetype\config;..\..\thirdparty\Freetype\include\freetype\internal;..\..\thirdparty\Freetype\include\freetype\internal\services;..\..\service\inc;..\..\subsystem\font;..\..\app\msg;..\..\app\activity_surface;..\..\app\activity_hrm;..\..\app\activity_setting;..\..\app\activity_menu;..\..\app\activity_card;..\..\app\activity_weather;..\..\app\activity_data;..\..\app\activity_alarm;..\..\subsystem\led\inc;..\..\subsystem\motar\inc;..\..\app\activity_system;..\..\app\sport;..\..\app\activity_sfc_option;..\..\app\activity_mijia;..\..\thirdparty\mbedtls-2.8.0\include;..\..\thirdparty\mbedtls-2.8.0\include\mbedtls;..\..\app\activity_charge;..\..\thirdparty\qr_code;..\..\app\activity_qrcode;..\..\app\activity_alarm_ring;..\..\app\activity_alert;..\..\subsystem\statistics\inc;..\..\bsp\apollo2\exactle\sw\hci\ambiq\em9304;..\..\bsp\apollo2\ambiq\profiles\ancc;..\..\bsp\apollo2\ambiq\apps\ancs;..\..\bsp\apollo2\exactle\sw\profiles\gatt;..\..\bsp\apollo2\exactle\sw\apps\wechat;..\..\app\activity_loading;..\..\app\activity_find_phone;..\..\bsp\apollo2\ambiq\apps\alipay;..\..\thirdparty\alipay;..\..\app\activity_alipay;..\..\bsp\apollo2\ambiq\profiles\alipay;..\..\thirdparty\barcode;..\..\app\activity_sport;..\..\thirdparty\SEGGER;..\..\app\activity_timer
  library: MicroLIB
  memory RVCT4: ROM 0xa000 size 0xc0000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\ryeex_sake.sct
  link misc: ../../bsp/apollo2/mcu/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group app
    ../../app/: main.c app_interface.c
    ../../subsystem/app_pm/src/: app_pm.c
    ../../app/msg/: gui_msg.c
    ../../app/activity_surface/: activity_surface.c
    ../../app/activity_hrm/: activity_hrm.c
    ../../app/activity_setting/: activity_setting.c
    ../../app/activity_menu/: activity_menu.c
    ../../app/activity_alarm_ring/: activity_alarm_ring.c
    ../../app/activity_card/: activity_card.c
    ../../app/activity_alarm/: activity_alarm.c
    ../../app/activity_data/: activity_data.c
    ../../app/activity_weather/: activity_weather.c
    ../../app/activity_system/: activity_system.c
    ../../app/activity_mijia/: activity_mijia.c
    ../../app/activity_sfc_option/: activity_sfc_option.c
    ../../app/activity_charge/: activity_charge.c
    ../../app/activity_qrcode/: activity_qrcode.c
    ../../app/activity_alert/: activity_alert.c
    ../../app/activity_loading/: activity_loading.c
    ../../app/activity_find_phone/: activity_find_phone.c
    ../../app/activity_alipay/: activity_alipay.c
    ../../app/activity_sport/: activity_sports.c
    ../../app/activity_timer/: activity_timer.c
  group bsp
    ../../bsp/apollo2/bsp/apollo2_evk_em9304/: am_bsp.c
    ../../bsp/: board.c board_control.c
    ../../bsp/apollo2/bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
    ../../bsp/components/mc36xx/: mcube_custom_config.c mcube_drv.c mcube_sample.c
    ../../bsp/components/bma456/: bma4.c bma456.c
    ../../bsp/apollo2/utils/: am_util_faultisr.c
  group subsystem_ble
    ../../subsystem/ble/src/: ble_task.c mible.c mible_arch.c mible_crypto.c mibeacon.c
    ../../subsystem/ble/inc/: device.pb.c fit_health.pb.c rbp.pb.c firmware.pb.c DataUpload.pb.c Property.pb.c Notification.pb.c Sport.pb.c Location.pb.c Gate.pb.c Weather.pb.c AlarmClock.pb.c BodyStatus.pb.c DevApp.pb.c Surface.pb.c transit.pb.c PhoneApp.pb.c DevLog.pb.c MiScene.pb.c DefaultCard.pb.c DevStatistics.pb.c Time.pb.c
    ../../subsystem/xfer/: r_xfer.c
  group subsystem_protocol
    ../../subsystem/protocol/src/: dip.c fhp.c nanopb_common.c rbp.c json.c apdu.c
  group subsystem_gsensor
    ../../subsystem/gsensor/src/: gsensor.c
  group subsystem_gui
    ../../subsystem/gui/src/: gui_support.c gui.c gui_bare.c gui_img.c scrollbar.c percent.c loading.c
    ../../thirdparty/ugfx/src/: gfx_mk.c
    ../../bsp/components/touch_oled/src/: am_devices_rm67162.c
    ../../thirdparty/ugfx/drivers/gdisp/rm67162/: gdisp_lld_rm67162.c
  group subsystem_tool
    ../../subsystem/tool/src/: ry_tool.c
  group subsystem_hrm
    ../../bsp/components/PPSI26X/src/: ppsi26x.c
    ../../subsystem/hrm/src/: hrm.c
    ../../bsp/components/PPSI26X/lib/: libAFE4410_DRIVERS_v2.0.0.0_2_partron_M4_Keil_FIFO25.lib liblifeqinside_5.2.4_13_m0.lib
  group subsystem_nfc
    ../../subsystem/nfc/pn80t/app/src/: apitest_handler.c ble_nfc_bridge.c callbacks.c firmware_image.c fw_dnd_mode_handler.c general_mode_handler.c nci_raw_mode_handler.c nfc_pn80t.c nvmem_handler.c se_mode_handler.c semi_standalone_mode_handler.c standalone_mode_handler.c testinput.c UserData_Storage.c ble_handler.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/dnld/: phDnldNfc.c phDnldNfc_Internal.c phDnldNfc_Utils.c phNxpNciHal_Dnld.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/hal/: phNxpNciHal.c phNxpNciHal_ext.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/log/: phNxpLog.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/osal/: phDal4Nfc_messageQueueLib.c phOsalNfc.c phOsalNfc_Log.c phOsalNfc_Thread.c phOsalNfc_Timer.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/self-test/: phNxpNciHal_SelfTest.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/tml/: phTmlNfc.c phTmlNfc_i2c.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/utils/: phNxpConfig.c phNxpNciHal_utils.c phNxpTransitConfig.c
    ../../subsystem/nfc/pn80t/halimpl/pn54x/: nfc_nci.c
    ../../subsystem/nfc/pn80t/lib/SeSupport/: SeSupport.c
    ../../subsystem/nfc/pn80t/lib/SeSupport/src/: Ala.c AlaLib.c AlaUtils.c example_ichannel.c JcDnld.c JcopOsDownload.c mop.c
    ../../subsystem/nfc/pn80t/SeApi/: nxp_impl_ichannel.c SeApi.c
    ../../subsystem/nfc/pn80t/SeApi/LogSupport/: SeApi_StatusDefinitions.c
    ../../subsystem/nfc/pn80t/src/adaptation/: android_logmsg.c config.c libmain.c NfcAdapt.c OverrideLog.c
    ../../subsystem/nfc/pn80t/src/gki/: gki_buffer.c gki_debug.c gki_osal.c gki_time.c
    ../../subsystem/nfc/pn80t/src/nfa/ce/: nfa_ce_act.c nfa_ce_api.c nfa_ce_main.c
    ../../subsystem/nfc/pn80t/src/nfa/dm/: nfa_dm_act.c nfa_dm_api.c nfa_dm_cfg.c nfa_dm_discover.c nfa_dm_main.c
    ../../subsystem/nfc/pn80t/src/nfa/ee/: nfa_ee_act.c nfa_ee_api.c nfa_ee_main.c
    ../../subsystem/nfc/pn80t/src/nfa/hci/: nfa_hci_act.c nfa_hci_api.c nfa_hci_ci.c nfa_hci_main.c nfa_hci_utils.c
    ../../subsystem/nfc/pn80t/src/nfa/sys/: nfa_sys_cback.c nfa_sys_cfg.c nfa_sys_main.c nfa_sys_ptim.c
    ../../subsystem/nfc/pn80t/src/nfc/nci/: nci_hmsgs.c nci_hrcv.c
    ../../subsystem/nfc/pn80t/src/nfc/nfc/: nfc_ee.c nfc_main.c nfc_ncif.c nfc_task.c nfc_test.c nfc_utils.c nfc_vs.c
    ../../subsystem/nfc/pn80t/src/nfc/tags/: ce_main.c
    ../../subsystem/nfc/pn80t/src/: nfca_version.c
    ../../subsystem/nfc/pn80t/lib/SeSupport/src/mop/: channelMgr.c registry.c sha1.c tlv.c utils.c vcDescription.c
  group subsystem_sensor_alg
    ../../subsystem/sensor_alg/src/: sensor_alg.c algorithm.lib sleepAlgo.lib
  group subsystem_testbench
    ../../subsystem/testbench/src/: testbench.c
  group subsystem_statistics
    ../../subsystem/statistics/src/: ry_statistics.c
  group ryapi
    ../../ryapi/src/: ry_ble.c ry_gui.c ry_gsensor.c ry_fs.c ry_nfc.c
  group hal
    ../../hal/src/: ry_hal_uart.c ry_hal_flash.c ry_hal_spi.c ry_hal_i2c_master.c ry_hal_rtc.c ry_hal_wdt.c ry_hal_gpio.c ry_hal_pwm.c ry_hal_spi_flash.c ry_hal_adc.c ry_hal_mcu.c
  group bsp_tp
    ../../bsp/components/touch_oled/src/: am_devices_CY8C4014.c communication_api.c cybtldr_api.c cybtldr_command.c cybtldr_entry.c cybtldr_parse.c
  group nanopb
    ../../thirdparty/nanopb/src/: pb_common.c pb_decode.c pb_encode.c
  group jsmn
    ../../thirdparty/jsmn/src/: jsmn.c jsmn_api.c
  group resources
    ../../resources/img/: circle.c
  group ryos
    ../../ryos/src/: ryos_event.c ryos_os.c ryos_timer.c ryos_module.c ryos_protocol.c ryos_update.c
  group os
    ../../thirdparty/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../thirdparty/FreeRTOS9/Source/portable/MemMang/: heap_4.c
    ../../thirdparty/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group am_ble
    ../../bsp/apollo2/ambiq/profiles/ancc/: ancc_main.c
    ../../bsp/apollo2/exactle/sw/profiles/gatt/: gatt_main.c
    ../../bsp/apollo2/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../../bsp/apollo2/exactle/sw/hci/ambiq/em9304/: em9304_patches.c hci_drv_em9304.c em9304_init.c
    ../../bsp/apollo2/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../bsp/apollo2/exactle/sw/stack/cfg/: cfg_stack.c
    ../../bsp/apollo2/exactle/sw/stack/hci/: hci_main.c
    ../../bsp/apollo2/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../bsp/apollo2/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../bsp/apollo2/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../bsp/apollo2/exactle/sw/services/: svc_batt.c svc_core.c svc_ryeex.c svc_dis.c svc_hrs.c svc_rscs.c svc_mi.c svc_wechat.c svc_alipay.c
    ../../bsp/apollo2/devices/: am_devices_em9304.c
    ../../bsp/apollo2/exactle/sw/apps/fit/: fit_main.c
    ../../bsp/apollo2/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../bsp/apollo2/exactle/sw/profiles/bas/: bas_main.c
    ../../bsp/apollo2/exactle/sw/profiles/rscp/: rscps_main.c
    ../../bsp/apollo2/exactle/sw/profiles/hrps/: hrps_main.c
    ../../bsp/apollo2/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../bsp/apollo2/ambiq/apps/ancs/: ancs_main.c
    ../../bsp/apollo2/exactle/sw/apps/wechat/: wechat_main.c
    ../../bsp/apollo2/ambiq/apps/alipay/: alipay_main.c
    ../../bsp/apollo2/ambiq/profiles/alipay/: alipay_vendor.c
  group am_drivers
    ../../bsp/apollo2/utils/: am_util_delay.c am_util_stdio.c am_util_time.c am_util_debug.c
  group lib
    ../../bsp/apollo2/mcu/hal/keil/bin/: libam_hal.lib
    ../../bsp/apollo2/exactle/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
    ../../bsp/apollo2/mcu/hal/: am_hal_iom.c am_hal_reset.c am_hal_debug.c
    ../../thirdparty/alipay/: unix_timestamp.c ALIPAY_IOT_band.lib
  group utils
    ../../utils/src/: ry_utils.c ry_log.c
  group keil
    ./: startup_keil.s
  group fatfs
    ../../thirdparty/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group xmodem
    ../../thirdparty/XMODEM/: resDFU.c
  group MD5
    ../../thirdparty/md5/: md5.c
  group subsystem_touch
    ../../subsystem/touch/src/: touch.c
  group scheduler
    ../../subsystem/sched/src/: scheduler.c
  group freeType
    ../../thirdparty/Freetype/src/truetype/: truetype.c
    ../../thirdparty/Freetype/src/base/: ftbase.c ftinit.c ftapi.c ftbbox.c ftbitmap.c ftdebug.c ftfstype.c ftgasp.c ftglyph.c ftgxval.c ftlcdfil.c ftmm.c ftotval.c ftpatent.c ftstroke.c ftsynth.c ftsystem.c
    ../../thirdparty/Freetype/src/otvalid/: otvalid.c
    ../../thirdparty/Freetype/src/sfnt/: sfnt.c
    ../../thirdparty/Freetype/src/smooth/: smooth.c
  group service
    ../../service/src/: data_management_service.c msg_management_service.c timer_management_service.c window_management_service.c device_management_service.c card_management_service.c app_management_service.c surface_management_service.c mijia_service.c storage_management_service.c
  group font
    ../../subsystem/font/: ry_font.c
  group subsystem_led
    ../../subsystem/led/src/: led.c
  group subsystem_motar
    ../../subsystem/motar/src/: motar.c
  group mbedtls
    ../../thirdparty/mbedtls-2.8.0/library/: aes.c des.c
  group qr_encode
    ../../thirdparty/qr_code/: qr_encode.c
  group alipay
    ../../thirdparty/barcode/: code128.c
