# Keil uVision project ryeex_sake.uvprojx, settings and files
target ryeex_sake (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: ryeex_sake
  AfterMake: fromelf --bin --output bin\ryeex_sake.bin bin\ryeex_sake.axf
  AfterMake: fromelf -cedrst --output bin\ryeex_sake.txt bin\ryeex_sake.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_PART_APOLLO2 AM_FREERTOS keil WSF_TRACE_ENABLED
  c misc: --diag_suppress=177  --diag_suppress=550
  c include: ..\..\bsp;..\..\bsp\apollo2\bsp\apollo2_evk_base;..\..\bsp\apollo2\devices;..\..\bsp\apollo2\freertos;..\..\bsp\apollo2\mcu;..\..\bsp\apollo2\mcu\hal;..\..\bsp\apollo2\mcu\regs;..\..\bsp\apollo2\utils;..\..\hal\inc;..\..\ryos\inc;..\..\thirdparty\FreeRTOS9\Source\include;..\..\thirdparty\FreeRTOS9\Source\portable\Keil\AMapollo2;..\..\utils\inc;..\..\ryapi\inc;..\..\bsp\apollo2\exactle\apollo-host\projects\common;..\..\bsp\apollo2\exactle\sw\apps\app;..\..\bsp\apollo2\exactle\sw\apps\app\include;..\..\bsp\apollo2\exactle\sw\apps\fit;..\..\bsp\apollo2\exactle\sw\hci\ambiq;..\..\bsp\apollo2\exactle\sw\hci\include;..\..\bsp\apollo2\exactle\sw\sec\common;..\..\bsp\apollo2\exactle\sw\sec\include;..\..\bsp\apollo2\exactle\sw\services;..\..\bsp\apollo2\exactle\sw\stack\cfg;..\..\bsp\apollo2\exactle\sw\stack\hci;..\..\bsp\apollo2\exactle\sw\stack\include;..\..\bsp\apollo2\exactle\ws-core\include;..\..\bsp\apollo2\exactle\ws-core\sw\util;..\..\bsp\apollo2\exactle\ws-core\sw\wsf\ambiq;..\..\bsp\apollo2\exactle\ws-core\sw\wsf\include;..\..\bsp\apollo2\exactle\sw\profiles\bas;..\..\bsp\apollo2\exactle\sw\profiles\hrps;..\..\bsp\apollo2\exactle\sw\profiles\rscp;..\..\bsp\apollo2\exactle\sw\profiles\uribeacon;..\..\subsystem\ble\inc;..\..\thirdparty\nanopb\inc;..\..\thirdparty\pt;..\..\bsp\components\mc36xx;..\..\bsp\apollo2\bootloader;..\..\thirdparty\nanopb\proto;..\..\bsp\components\bma456;..\..\subsystem\protocol\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\ryeex_sake.sct
  link misc: ../../bsp/apollo2/mcu/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group keil
    ./: startup_keil.s
  group lib
    ../../bsp/apollo2/mcu/hal/keil/bin/: libam_hal.lib
    ../../bsp/apollo2/exactle/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
  group app
    ../../app/: main.c
  group bsp
    ../../bsp/: board.c
    ../../bsp/apollo2/bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
    ../../bsp/components/oled_ug7228/: oled_ug7228.c
    ../../bsp/components/mc36xx/: mcube_custom_config.c mcube_drv.c mcube_sample.c
    ../../bsp/components/bma456/: bma4.c bma456.c
    ../../bsp/apollo2/bsp/apollo2_evk_base/: am_bsp.c
  group am_drivers
    ../../bsp/apollo2/utils/: am_util_delay.c am_util_stdio.c am_util_time.c am_util_debug.c
  group hal
    ../../hal/src/: ry_hal_uart.c ry_hal_flash.c ry_hal_spi.c ry_hal_i2c_master.c ry_hal_rtc.c ry_hal_wdt.c
  group ryos
    ../../ryos/src/: ryos_event.c ryos_os.c ryos_timer.c ryos_module.c ryos_protocol.c ryos_update.c
  group os
    ../../thirdparty/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../thirdparty/FreeRTOS9/Source/portable/MemMang/: heap_4.c
    ../../thirdparty/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group utils
    ../../utils/src/: ry_utils.c
  group am_ble
    ../../bsp/apollo2/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../../bsp/apollo2/exactle/sw/hci/ambiq/em9304/: em9304_patches.c hci_drv_em9304.c
    ../../bsp/apollo2/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../bsp/apollo2/exactle/sw/stack/cfg/: cfg_stack.c
    ../../bsp/apollo2/exactle/sw/stack/hci/: hci_main.c
    ../../bsp/apollo2/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../bsp/apollo2/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../bsp/apollo2/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../bsp/apollo2/exactle/sw/services/: svc_batt.c svc_core.c svc_ryeex.c svc_dis.c svc_hrs.c svc_rscs.c svc_mi.c
    ../../bsp/apollo2/devices/: am_devices_em9304.c
    ../../bsp/apollo2/exactle/sw/apps/fit/: fit_main.c
    ../../bsp/apollo2/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../bsp/apollo2/exactle/sw/profiles/bas/: bas_main.c
    ../../bsp/apollo2/exactle/sw/profiles/rscp/: rscps_main.c
    ../../bsp/apollo2/exactle/sw/profiles/hrps/: hrps_main.c
    ../../bsp/apollo2/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
  group subsystem_ble
    ../../subsystem/ble/src/: ble_task.c mible.c mible_arch.c mible_crypto.c reliable_xfer.c
    ../../subsystem/ble/inc/: binding.pb.c device.pb.c fit_health.pb.c rbp.pb.c
  group ryapi
    ../../ryapi/src/: ry_ble.c ry_gui.c ry_gsensor.c
  group nanopb
    ../../thirdparty/nanopb/src/: pb_common.c pb_decode.c pb_encode.c
  group subsystem_protocol
    ../../subsystem/protocol/src/: dip.c fhp.c nanopb_common.c rbp.c
  group subsystem_gsensor
    ../../subsystem/gsensor/src/: gsensor.c
